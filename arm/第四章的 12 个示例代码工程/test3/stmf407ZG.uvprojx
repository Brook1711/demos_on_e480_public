# Keil uVision project stmf407ZG.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stmf407ZG
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS:NN Lib 1.1.0, USB:CORE 6.13.0, CMSIS Driver:I2C 2.8, CMSIS Driver:USART 2.10, Device:Startup 2.6.2
